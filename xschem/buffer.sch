** sch_path: xschem/buffer.sch
**.subckt buffer A Vp Vn Y
*.ipin A
*.iopin Vp
*.iopin Vn
*.opin Y
X1 A Vn Vp net1 inverter
X2 net1 Vn Vp Y inverter
**.ends
.end
